# Keil uVision project TEST.uvproj, settings and files
target TEST (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: TEST +hex
  c flags: Optim=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: .\CORE;.\USER;.\STM32F10x_FWLib\inc;.\USB\CFG;.\USB\CORE;.\FATFS\src;.\LCD;.\GUI;.\COMM
  library: MicroLIB
  memory RVCT4: ROM 0x8003000 size 0x17800
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./USER/: main.c stm32f10x_it.c system_stm32f10x.c spi.c Ext_Flash.c time.c beep.c key.c adc.c cfg.c ppm_decode.c flash.c
  group CORE
    ./CORE/: core_cm3.c startup_stm32f10x_md.s
  group FWLIB
    ./STM32F10x_FWLib/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_dma.c stm32f10x_adc.c stm32f10x_tim.c stm32f10x_exti.c misc.c stm32f10x_flash.c
  group USB
    ./USB/CORE/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c
  group USBCFG
    ./USB/CFG/: hw_config.c mass_mal.c memory.c scsi_data.c usb_bot.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c usb_scsi.c
  group FATFS
    ./FATFS/src/: diskio.c ff.c
  group LCD
    ./LCD/: lcd.c
  group GUI
    ./GUI/: Page.c PMain.c PTrim.c MTimer.c MStick.c PMenuMain.c PMenuAero.c PMenuHeli.c PMonitor.c PMenuModel.c PMenuSys.c PMenuBack.c PAbout.c P_Rev.c P_Epa.c P_Neu.c P_Curve.c P_AuxCh.c P_Mixer.c P_Delta.c P_Vtail.c P_FlpAil.c P_ThrMix.c P_YawMix.c P_Delay.c P_Gyro.c P_Swash.c PModelSel.c PModelCopy.c PEdtName.c PIconSel.c PMenuRf.c PEdtId.c PBind.c PChMap.c PTimerSet.c PSwDef.c PMenuTr.c PTrChMap.c PStkCal.c PEdtTime.c P_VirtualSw.c P_AilRud.c P_Free.c
  group COMM.
    ./COMM/: rf_spi.c cc2500.c Tx.c Tx_PPM.c RCB6i.lib RCB-OS10.lib
